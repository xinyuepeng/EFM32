# IAR project ClockManage.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG840F32 EnergyMicro EFM32TG840F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG840F32
  ICCARM.CCIncludePath2: C:\Documents and Settings\hxin\Application Data\energymicro\CMSIS\Include; C:\Documents and Settings\hxin\Application Data\energymicro\Device\EnergyMicro\EFM32TG\Include; C:\Documents and Settings\hxin\Application Data\energymicro\emlib\inc; C:\Documents and Settings\hxin\Application Data\energymicro\kits\common\drivers; C:\Documents and Settings\hxin\Application Data\energymicro\kits\common\bsp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ClockManage.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
